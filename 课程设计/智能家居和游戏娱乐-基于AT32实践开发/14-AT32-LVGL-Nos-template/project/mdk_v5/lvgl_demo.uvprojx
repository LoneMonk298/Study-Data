# Keil uVision project lvgl_demo.uvprojx, settings and files
target lvgl_desktop_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lvgl_desktop_demo +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: AT32F435VGT7, AT_START_F435_V1, USE_STDPERIPH_DRIVER,AT_SURF_F437_V1,HAVE_CONFIG_H,LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --locale=english
  c include: ..\..\..\middlewares\3rd_party\lvgl;..\..\..\middlewares\3rd_party\lvgl\demos;..\..\..\middlewares\3rd_party\lvgl\demos\benchmark;..\..\..\middlewares\3rd_party\lvgl\demos\keypad_encoder;..\..\..\middlewares\3rd_party\lvgl\demos\music;..\..\..\middlewares\3rd_party\lvgl\demos\music\assets;..\..\..\middlewares\3rd_party\lvgl\demos\stress;..\..\..\middlewares\3rd_party\lvgl\demos\widgets;..\..\..\middlewares\3rd_party\lvgl\examples;..\..\..\middlewares\3rd_party\lvgl\examples\anim;..\..\..\middlewares\3rd_party\lvgl\examples\assets;..\..\..\middlewares\3rd_party\lvgl\examples\event;..\..\..\middlewares\3rd_party\lvgl\examples\get_started;..\..\..\middlewares\3rd_party\lvgl\examples\layouts;..\..\..\middlewares\3rd_party\lvgl\examples\layouts\flex;..\..\..\middlewares\3rd_party\lvgl\examples\layouts\grid;..\..\..\middlewares\3rd_party\lvgl\examples\libs;..\..\..\middlewares\3rd_party\lvgl\examples\libs\bmp;..\..\..\middlewares\3rd_party\lvgl\examples\libs\ffmpeg;..\..\..\middlewares\3rd_party\lvgl\examples\libs\freetype;..\..\..\middlewares\3rd_party\lvgl\examples\libs\gif;..\..\..\middlewares\3rd_party\lvgl\examples\libs\png;..\..\..\middlewares\3rd_party\lvgl\examples\libs\qrcode;..\..\..\middlewares\3rd_party\lvgl\examples\libs\rlottie;..\..\..\middlewares\3rd_party\lvgl\examples\libs\sjpg;..\..\..\middlewares\3rd_party\lvgl\examples\others;..\..\..\middlewares\3rd_party\lvgl\examples\others\gridnav;..\..\..\middlewares\3rd_party\lvgl\examples\others\monkey;..\..\..\middlewares\3rd_party\lvgl\examples\others\snapshot;..\..\..\middlewares\3rd_party\lvgl\examples\porting;..\..\..\middlewares\3rd_party\lvgl\examples\scroll;..\..\..\middlewares\3rd_party\lvgl\examples\styles;..\..\..\middlewares\3rd_party\lvgl\examples\widgets;..\..\..\middlewares\3rd_party\lvgl\src;..\..\..\middlewares\3rd_party\lvgl\src\core;..\..\..\middlewares\3rd_party\lvgl\src\draw;..\..\..\middlewares\3rd_party\lvgl\src\extra;..\..\..\middlewares\3rd_party\lvgl\src\extra\layouts;..\..\..\middlewares\3rd_party\lvgl\src\extra\layouts\flex;..\..\..\middlewares\3rd_party\lvgl\src\extra\layouts\grid;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\bmp;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\ffmpeg;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\freetype;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\fsdrv;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\gif;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\png;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\qrcode;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\rlottie;..\..\..\middlewares\3rd_party\lvgl\src\extra\libs\sjpg;..\..\..\middlewares\3rd_party\lvgl\src\extra\others;..\..\..\middlewares\3rd_party\lvgl\src\extra\others\gridnav;..\..\..\middlewares\3rd_party\lvgl\src\extra\others\monkey;..\..\..\middlewares\3rd_party\lvgl\src\extra\others\snapshot;..\..\..\middlewares\3rd_party\lvgl\src\extra\themes;..\..\..\middlewares\3rd_party\lvgl\src\extra\themes\basic;..\..\..\middlewares\3rd_party\lvgl\src\extra\themes\default;..\..\..\middlewares\3rd_party\lvgl\src\extra\themes\mono;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\animimg;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\calendar;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\chart;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\colorwheel;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\imgbtn;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\keyboard;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\led;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\list;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\menu;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\meter;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\msgbox;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\span;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\spinbox;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\spinner;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\tabview;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\tileview;..\..\..\middlewares\3rd_party\lvgl\src\extra\widgets\win;..\..\..\middlewares\3rd_party\lvgl\src\font;..\..\..\middlewares\3rd_party\lvgl\src\hal;..\..\..\middlewares\3rd_party\lvgl\src\misc;..\..\..\middlewares\3rd_party\lvgl\src\widgets;..\inc;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\at_surf_f437_board;..\..\..\libraries\drivers\inc;..\..\..\middlewares\i2c_application_library;..\..\..\middlewares\3rd_party\lvgl\examples\arduino;..\..\..\middlewares\3rd_party\lvgl\freetype\include;..\..\..\middlewares\3rd_party\fatfs\source;..\..\..\examples\audio\libmad;..\..\..\examples\audio\libmad\msvc++;..\..\custom;..\..\lvgl_user\guider_customer_fonts;..\..\lvgl_user\guider_fonts;..\..\lvgl_user\images;..\..\lvgl_user;..\..\my_img;..\..\..\libraries\at32f435_437_board;..\..\..\libraries\at32_bsp;..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xb0000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: main.c at32f435_437_clock.c at32f435_437_int.c lv_tick_custom.c
  group bsp
    ../../../bsp/: bsp.c bsp.eep_lm75.c bsp_beep.c bsp_esp12.c bsp_gt911.c bsp_key.c bsp_lcd.c bsp_oled.c bsp_oledfont.c bsp_queue.c bsp_timer.c bsp_uart.c bsp_ext_flash.c bsp_ext_flash.h
  group firmware
    ../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_dma.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_xmc.c at32f435_437_scfg.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_exint.c at32f435_437_qspi.c
    ../../../middlewares/i2c_application_library/: i2c_application.c
  group cmsis
    ../src/: system_at32f435_437.c
    ./: startup_at32f435_437.s
  group lv_src
    ../../../middlewares/3rd_party/lvgl/src/core/: lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c lv_disp.c
    ../../../middlewares/3rd_party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../middlewares/3rd_party/lvgl/src/extra/: lv_extra.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../middlewares/3rd_party/lvgl/src/extra/widgets/win/: lv_win.c
    ../../../middlewares/3rd_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../middlewares/3rd_party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../middlewares/3rd_party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../middlewares/3rd_party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../../middlewares/3rd_party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../../middlewares/3rd_party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../middlewares/3rd_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../middlewares/3rd_party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../middlewares/3rd_party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../middlewares/3rd_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../middlewares/3rd_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../middlewares/3rd_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../middlewares/3rd_party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../middlewares/3rd_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lv_porting
    ../../../middlewares/3rd_party/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl_user
    ../../lvgl_user/: events_init.c gui_guider.c setup_scr_screen_1.c setup_scr_screen_2.c setup_scr_screen_3.c setup_scr_screen_4.c setup_scr_main_screen.c gomoku.c gomoku.h music.c music.h tlink.c tlink.h time_manager.c time_manager.h
  group custom
    ../../custom/: custom.c
  group readme
    ../: readme.txt
  group picFont
    ../../lvgl_user/guider_customer_fonts/: myFont.c
    ../../lvgl_user/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_simsun_18.c
    ../../lvgl_user/images/: _102_alpha_60x50.c _104_alpha_50x50.c _105_alpha_60x50.c _106_alpha_50x50.c _1_alpha_284x226.c _11_alpha_100x100.c _22_alpha_100x100.c _33_alpha_100x100.c
