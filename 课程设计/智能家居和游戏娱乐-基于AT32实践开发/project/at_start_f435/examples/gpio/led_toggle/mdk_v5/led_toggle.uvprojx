# Keil uVision project led_toggle.uvprojx, settings and files
target led_toggle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f435_437_board;..\..\..\..\..\..\middlewares\i2c_application_library;.\objects;..\mdk_v5;..\..\..\..\..\..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ../../../../../at32f435_437_board/: at32f435_437_board.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
    ../../../../../../bsp/: bsp.eep_lm75.c bsp.eep_lm75.h bsp.c bsp_beep.c bsp_key.c bsp_timer.c bsp_uart.c bsp_esp12.c bsp_uart.h bsp_gt911.c bsp_lcd.c bsp_oled.c bsp_oledfont.c bsp_queue.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f435_437_gpio.c at32f435_437_crm.c at32f435_437_usart.c at32f435_437_misc.c at32f435_437_tmr.c at32f435_437_dma.c at32f435_437_i2c.c at32f435_437_adc.c at32f435_437_xmc.c at32f435_437_spi.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
